# Keil uVision project 01_bootloader_no_interrupt_vector.uvprojx, settings and files
target 01App (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_bootloader_no_interrupt_vector +hex
  AfterMake: fromelf  --bin  --output=app.bin   .\Objects\01_bootloader_no_interrupt_vector.axf
  AfterMake: fromelf  --text  -a -c  --output=app.dis   .\Objects\01_bootloader_no_interrupt_vector.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\drv;.\drv\led;.\drv\usart
  memory RVCT4: ROM 0x800b000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\app.sct
  group app
    ./app/: main.c
  group drv
    ./drv/usart/: usart.c
  group startup
    ./startup/: start.s
